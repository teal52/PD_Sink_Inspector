# Repository teal52/PD_Sink_Inspector

## KiCad design PdSinkInspector.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C10, C12, C14, C17: 0.1uF; C_0402_1005Metric
C8, C11, C20, C21: 1uF; C_0402_1005Metric
C13, C18, C19: 10uF; C_0402_1005Metric
C15, C16: 27pF; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
D2: SS14; D_SMA
D3, D4, D5: D; D_SOD-882
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC2: STUSB4700YQTR; QFN50P400X400X90-25N-D; Mouser Part Number 511-STUSB4700YQTR
J1, J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: Conn_01x12_Socket; Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal
L1: 1.5uH; L_0805_2012Metric
Q1, Q2, Q3: AO3401A; SOT-23
R1, R2: 27; R_0402_1005Metric
R3, R17: NC; R_0603_1608Metric
R4: 100k; R_0402_1005Metric
R5, R6, R7: 1k; R_0402_1005Metric
R8, R9, R11, R12: 10k; R_0402_1005Metric
R10: 2k2; R_0402_1005Metric
R13, R14: 5.1k; R_0402_1005Metric
R15, R16: 4.7k; R_0402_1005Metric
R18: 10; R_0402_1005Metric
SW1, SW2: SW_MEC_5E; ABMM2
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U3: TPS63031DSK; WSON-10-1EP_2.5x2.5mm_P0.5mm_EP1.2x2mm
Y2: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C9.1, C10.1, C11.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C12.1, C18.1, C19.1, J2.4, R3.1, R8.1, R15.1, R16.1, R18.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.8 (VCC), U3.1 (VOUT), U3.10 (FB)
BOOT: R5.1, SW2.1, SW2.2
Data/Command: J2.7, U1.35 (GPIO23)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D1.1 (K), D3.2 (A), D4.2 (A), D5.2 (A), IC2.3 (VCONN), IC2.6 (RESET), IC2.10 (GND), IC2.25 (EP), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J2.2, J2.5, J2.6, J2.12, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R4.1, R12.1, R13.2, R14.2, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A), U1.19 (TESTEN), U1.57 (GND), U2.4 (GND), U3.3 (PGND), U3.9 (GND), U3.11 (PGND), Y2.2, Y2.4
LCD_RESET: J2.11, U1.36 (GPIO24)
MISO: U1.11 (GPIO8)
MOSI: J2.10, U1.14 (GPIO11)
unnamed: C16.1, R6.1, Y2.1
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), D3.1 (K), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: IC2.2 (CC1), J1.A5 (CC1)
unnamed: IC2.4 (CC2), J1.B5 (CC2)
unnamed: IC2.7 (SCL), R15.2, U1.9 (GPIO7)
unnamed: IC2.8 (SDA), R16.2, U1.8 (GPIO6)
unnamed: IC2.19 (VBUS_DISCH), Q3.1 (G), R11.1
unnamed: IC2.20 (VBUS_EN_SRC), R10.1
unnamed: C20.1, IC2.21 (VREG_1V2)
unnamed: C21.1, IC2.23 (VREG_2V7)
unnamed: IC2.13 (VVAR_ADDR0), R4.2
unnamed: J2.3, R18.1
unnamed: J3.A5 (CC1), R14.1
unnamed: J3.B5 (CC2), R13.1
unnamed: Q1.1 (G), Q2.1 (G), R9.1, R10.2
unnamed: Q1.2 (S), Q2.2 (S), R9.2
unnamed: Q3.3 (D), R12.2
unnamed: U1.52 (QSPI_SCLK), U2.6 (CLK)
unnamed: U1.53 (QSPI_SD0), U2.5 (DI(IO0))
unnamed: U1.55 (QSPI_SD1), U2.2 (DO(IO1))
unnamed: U1.54 (QSPI_SD2), U2.3 (IO2)
unnamed: U1.51 (QSPI_SD3), U2.7 (IO3)
unnamed: R3.2, R5.2, U1.56 (QSPI_SS), U2.1 (~CS)
unnamed: R2.2, U1.46 (USB_DM)
unnamed: R1.2, U1.47 (USB_DP)
unnamed: C15.1, R17.2, U1.20 (XIN), Y2.3
unnamed: R6.2, R17.1, U1.21 (XOUT)
unnamed: C14.1, U3.6 (EN), U3.7 (PS/SYNC), U3.8 (VINA)
unnamed: L1.1, U3.4 (L1)
unnamed: L1.2, U3.2 (L2)
RESET: C17.1, R8.2, SW1.1, SW1.2, U1.26 (RUN)
SPI_CS: J2.8, U1.12 (GPIO9)
SPI_SCK: J2.9, U1.13 (GPIO10)
USB_D+: D4.1 (K), J3.A6 (D+), J3.B6 (D+), R1.1
USB_D-: D5.1 (K), J3.A7 (D-), J3.B7 (D-), R2.1
VBUS: C13.1, D2.1 (K), IC2.22 (VSYS), IC2.24 (VDD), Q2.3 (D), Q3.2 (S), R7.1, R11.2, U3.5 (VIN)
Vout: IC2.18 (VBUS_SENSE), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q1.3 (D)

Notes on the sheet:
ネジ穴
USB Input
PWR_FLAG(お作法)
MCU&PD_IC

Board: 2 copper layers, 62.0 x 50.0 mm, 61 parts (1 on the bottom side), 44 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C12, C14, C17, C2, C3, C4, C5, C6, C7, C9",0402,12,0.1uF,
"C11, C20, C21, C8",0402,4,1uF,
"C13, C18, C19",0402,3,10uF,
"C15, C16",0402,2,27pF,
D1,0603,1,LED,
D2,D_SMA,1,SS14,
"D3, D4, D5",D_SOD-882,3,D,
IC2,QFN50P400X400X90-25N-D,1,STUSB4700YQTR,
"J1, J3",USB_C_Receptacle_G-Switch_GT-USB-7010ASV,2,USB_C_Receptacle_USB2.0_16P,
J2,Hirose_FH12-12S-0.5SH_1x12-1MP_P0.50mm_Horizontal,1,Conn_01x12_Socket,
L1,0805,1,1.5uH,
"Q1, Q2, Q3",SOT-23,3,AO3401A,
"R1, R2",0402,2,27,
R10,0402,1,2k2,
"R11, R12, R8, R9",0402,4,10k,
"R13, R14",0402,2,5.1k,
"R15, R16",0402,2,4.7k,
"R17, R3",0603,2,NC,
R4,0402,1,100k,
"R5, R6, R7",0402,3,1k,
"SW1, SW2",ABMM2,2,SW_MEC_5E,
U1,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm,1,RP2040,
U2,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,
U3,WSON-10-1EP_2.5x2.5mm_P0.5mm_EP1.2x2mm,1,TPS63031DSK,
Y2,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,Crystal_GND24,

## Commit log

2025-02-09 [Add]メインで使用するICをセット
2025-02-09 [Update]RP2040を結線
2025-02-11 LDO、Flash追加
2025-03-30 2025/03/30
2025-03-31 i2cにプルアップ追加+JLC用にBOM作成(途中)
2025-04-06 LCSCセット
2025-04-06 [Update]基板配置してみた
2025-04-07 [Update]基板配線開始+チップを0402に変更
2025-04-13 4/13進捗
2025-04-13 [Update]ガーバー作成
2025-04-13 [Fix]不要なレベル変換を削除
2025-04-14 [Update]シルクの印字調整
